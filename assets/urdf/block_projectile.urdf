Commit message: RLTask

File: assets/urdf/block_projectile.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link object: geometry collision box size=0.2 0.2 0.2
